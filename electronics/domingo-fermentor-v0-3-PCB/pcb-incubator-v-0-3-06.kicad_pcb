# Repository domingoclub/domingo-fermenter-lab

File README.md:

# Domingo Fermenter Lab

> An open-source fermenter that promotes fermented food and collaboration with natural processes.
 
At [Domingo Club](https://domingoclub.com/), we make fermented food, open-source tools and explore collaboration with natural processes to promote understanding, transparency, resilience and equity in our global food system.

We're developing an open-source fermenter that can be easily fabricated anywhere to promote fermented plant-based protein (tempeh) everywhere. An fermenter is a device that maintains the necessary parameters for an environment suitable for the growth of mycelium (the vegetative part of fungi) and microorganisms of all kinds.

## For kitchen scientists

Our Fermenter Lab can incubate 18 large Petri dishes at the desired temperature. It's the ideal incubator for kitchen scientists, allowing you to experiment with all kinds of fermentation processes, as well as new biomaterials and mycelium-based objects.

It features an integrated interface for choosing your fermentation/incubation mode, a heating system consisting of three heat pads and two fans to distribute the heat evenly throughout the fermenter, a digital temperature sensor, and three shelves that can be pulled out and placed on top of the fermenter to free up volume if required.

## Reaching the ideal temperature

The Fermenter Lab allows you to reach the ideal temperature for the development of your micro-organisms. For rhizopus (the fungus used for tempeh), for example, we vary the temperature from 32°C to 27°C over a period of two days, to achieve perfect development. These incubation/fermentation modes can be easily modified/created by connecting the fermenter to a computer via a usb cable, if for example you want to create a reishi mode, which swings from 29°C to 26°C over a period of 6 days.

## Make it yours

The Fermenter Lab was designed from the ground up to be easily assembled and disassembled. The fabrication plans and software of the fermenter are open-source, so you can repair it, improve it, hack into it or simply make it your own. The electronics are designed to be as standard as possible, so that they can be understood and last over time. It uses a Raspberry Pico as the brain and a customised circuit board to easily connect the various components needed for the fermenter to work properly.

## Find out more

- [Fermenter Software](https://github.com/domingoclub/fermenter-software)
- [Read the full documentation](https://domingoclub.com/projects/domingo-fermenter-lab/doc)
- [Buy it ready made](https://domingoclub.com/products/domingo-fermenter-lab)

Domingo Club → [domingoclub.com](https://domingoclub.com) & [instagram.com/domingoclub](https://instagram.com/domingoclub/)

## KiCad design electronics/domingo-fermentor-v0-3-PCB/pcb-incubator-v-0-3-06.kicad_pcb

Parts:
C1, C2: 10uF; C_1206
D2: LED_RGB_CLV1A-FKB; LED_RGB_Cree_CLV1A-FKB_3.2x2.8mm
D3: DIODESOD123; SOD-123
J1: connector-heatingpad-1; NS-Tech_Grove_1x04_P2mm_Vertical; PARTREV A
J2: connector-heatingpad-2; NS-Tech_Grove_1x04_P2mm_Vertical; PARTREV A
J3: connector-fan; NS-Tech_Grove_1x04_P2mm_Vertical; PARTREV A
J4: connector-sensor; NS-Tech_Grove_1x04_P2mm_Vertical; PARTREV A
J5: Barrel_Jack_Switch; BarrelJack_Wuerth_6941xx301002
M1: SPDTSWITCH; toggle_switch_SPDT
M2: PINHD-1x04-HEADER; 128x64OLED
Q1, Q2: MOSFET_N-CH_50V_16A; TO-252
R2, R3, R4: 220R; R_1206
R5, R6, R7, R8: 10K; R_1206
S1, S2, S3, S4: 6MM_SWITCH6MM_SWITCH-fab; Button_Omron_B3SN_6x6mm-throughhole
U1: Pico; RPi_Pico_SMD_TH-modified
U2: Regulator_Linear_NCP1117-5.0V-1A; SOT-223-3_TabPin2

Connections:
3V3: D2.2 (A), J4.2, M2.1, U1.36 (3V3)
5V: C2.1, U1.40 (VBUS), U2.2 (VO)
12V: C1.1, D3.2 (CATHODE), J1.2, J2.2, J3.2, M1.3, R6.1, U2.3 (VI)
12VIN: J5.1, M1.2
BTN-1: S1.1, U1.25 (GPIO19)
BTN-2: S2.1, U1.24 (GPIO18)
BTN-3: S3.1, U1.22 (GPIO17)
BTN-4: S4.1, U1.21 (GPIO16)
FAN: Q2.1 (G), R8.1, U1.9 (GPIO6)
GND: C1.2, C2.2, J4.1, J5.2, J5.3, M2.2, Q1.2 (S), Q2.2 (S), R5.2, R8.2, S1.2 (S), S2.2 (S), S3.2 (S), S4.2 (S), U1.3 (GND), U1.13 (GND), U1.23 (GND), U1.33 (AGND), U1.38 (GND), U2.1 (GND)
HEATING-PAD: Q1.1 (G), R5.1, U1.7 (GPIO5)
I2C-1-SCL: M2.3, U1.32 (GPIO27_ADC1)
I2C-1-SDA: M2.4, U1.31 (GPIO26_ADC0)
I2C-2-SCL: J4.4, U1.17 (GPIO13)
I2C-2-SDA: J4.3, U1.16 (GPIO12)
LED-B: R4.2, U1.26 (GPIO20)
LED-G: R3.2, U1.27 (GPIO21)
LED-R: R2.2, U1.29 (GPIO22)
unnamed: D2.1 (RK), R2.1
unnamed: D2.3 (BK), R4.1
unnamed: D2.4 (GK), R3.1
unnamed: D3.1 (ANODE), R7.1
unnamed: J1.1, J2.1, Q1.3 (D), R6.2
unnamed: J3.1, Q2.3 (D), R7.2

Notes on the sheet:
Incubator v-0-3
DC Jack
Voltage regulator 12V to 5V
RGB LED
Heating Pad (12V)
Fan (12V)
Sensor SHT31 (I2C)
OLED Display (I2C)
Power switch
Buttons

Board: 2 copper layers, 122.9 x 58.4 mm, 26 parts (4 on the bottom side), 24 nets.

## Commit log

2021-11-18 readme update
2021-11-18 license
2021-11-18 electronics files
2021-11-18 cabinet files
2022-03-08 shelves and door lock added
2022-03-08 shelves and door lock addes
2022-03-16 added link to code
2022-03-16 linebreak
